IMAGE_FEATURES += "nmtui"
